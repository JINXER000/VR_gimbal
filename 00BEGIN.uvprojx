# Keil uVision project 00BEGIN.uvprojx, settings and files
target uart_echo (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_echo +hex
  AfterMake: fromelf --bin --output .\rvmdk\uart_echo.bin .\rvmdk\uart_echo.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA0
  c misc: --c99
  c include: .\inc;.\driverlib;..\11BEGIN;.\driverlib\rvmdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: uart_echo.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S chuankou.c main.c duoji.c yaogan.c buttons.c ramp.c mypid.c
  group Libraries
    ./driverlib/rvmdk/: driverlib.lib
    ./driverlib/: uart.c pwm.c
  group Documentation
    ./: readme.txt
software components: CMSIS:CORE 4.3.0
